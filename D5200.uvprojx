# Keil uVision project D5200.uvprojx, settings and files
target NB-IoT_TestTerminal (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NB-IoT_TestTerminal +hex
  BeforeMake: beforeBuild.bat
  AfterMake: C:/keil_v5/ARM/ARMCC/bin/fromelf.exe  -bin -o ./Objects/NB-IoT_TestTerminal.bin ./Objects/NB-IoT_TestTerminal.axf
  AfterMake: afterBuild.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --locale=english
  c include: .\CMSIS;.\FWlib\inc;.\User;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\SYSTEM\delay;.\SYSTEM\sys;.\HAL\TIMER;.\HAL\USART;.\FreeRTOS-Plus\FreeRTOS-Plus-CLI;.\HAL\COMMON;.\M5310;.\HAL\CLI;.\HAL\LCD;.\HAL\GUI;.\HAL\KEY;.\HAL\ADC;.\HAL\BLUETOOTH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartCode
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_it.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group USART
    ./HAL/USART/: usart.c
  group TIMER
    ./HAL/TIMER/: timer.c
  group COMMON
    ./HAL/COMMON/: common.c
  group FreeRTOS_CLI
    ./FreeRTOS-Plus/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c User_Cli.c
  group M5310
    ./M5310/: m5310.c
  group LCD
    ./HAL/LCD/: st7789s.c
  group GUI
    ./HAL/GUI/: ui.c
  group KEY
    ./HAL/KEY/: key.c
  group ADC
    ./HAL/ADC/: adc.c
  group BLUETOOTH
    ./HAL/BLUETOOTH/: bluetooth.c
